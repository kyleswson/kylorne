# Repository kyleswson/kylorne

## KiCad design Kylorne/Kylorne.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22: D; D3_TH_SMD
J1: MJ-4PP-9
J2: OLED
J3: LED; StripLED_rev
JP1: JP
JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9: Jumper
L1, L2, L3, L4, L5, L6: SK6812MINI; SK6812MINI_underglow
L7, L8, L9, L10, L11, L12, L13, L14, L15, L16, L17, L18, L19, L20, L21, L22, L23, L24, L25, L26, L27, L28: SK6812MINI; SK6812MINI_rev
P1, P2: i2c-pin; 1pin_conn
R1, R2: R
RSW1: SW_PUSH; ResetSW
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20: SW_PUSH; MX_ALPS_PG1350_noLed
SW21, SW22: SW_PUSH; MX_ALPS_PG1350_noLed_1.75u
U1: ProMicro; ProMicro_v2

Connections:
GND: J1.C, J3.1, JP2.1, JP9.1, L1.2 (VSS), L2.2 (VSS), L3.2 (VSS), L4.2 (VSS), L5.2 (VSS), L6.2 (VSS), L7.2 (VSS), L8.2 (VSS), L9.2 (VSS), L10.2 (VSS), L11.2 (VSS), L12.2 (VSS), L13.2 (VSS), L14.2 (VSS), L15.2 (VSS), L16.2 (VSS), L17.2 (VSS), L18.2 (VSS), L19.2 (VSS), L20.2 (VSS), L21.2 (VSS), L22.2 (VSS), L23.2 (VSS), L24.2 (VSS), L25.2 (VSS), L26.2 (VSS), L27.2 (VSS), L28.2 (VSS), RSW1.2, U1.3 (GND), U1.4 (GND), U1.23 (GND)
LED: J3.2, L3.3 (DIN), U1.1 (TX)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: J1.A, P1.1
unnamed: J1.B, JP1.2, P2.1
unnamed: J2.1, JP5.2, JP9.2
unnamed: J2.2, JP4.2, JP8.2
unnamed: J2.3, JP3.2, JP7.2
unnamed: J2.4, JP2.2, JP6.2
unnamed: L1.3 (DIN), L2.1 (DOUT)
unnamed: L1.1 (DOUT), L4.3 (DIN)
unnamed: L2.3 (DIN), L3.1 (DOUT)
unnamed: L4.1 (DOUT), L5.3 (DIN)
unnamed: L5.1 (DOUT), L6.3 (DIN)
unnamed: L7.3 (DIN), L8.1 (DOUT)
unnamed: L10.3 (DIN), L16.1 (DOUT)
unnamed: L9.3 (DIN), L10.1 (DOUT)
unnamed: L11.3 (DIN), L12.1 (DOUT)
unnamed: L11.1 (DOUT), L17.3 (DIN)
unnamed: L12.3 (DIN), L18.1 (DOUT)
unnamed: L7.1 (DOUT), L13.3 (DIN)
unnamed: L13.1 (DOUT), L19.3 (DIN)
unnamed: L14.3 (DIN), L20.1 (DOUT)
unnamed: L8.3 (DIN), L14.1 (DOUT)
unnamed: L9.1 (DOUT), L15.3 (DIN)
unnamed: L15.1 (DOUT), L21.3 (DIN)
unnamed: L16.3 (DIN), L22.1 (DOUT)
unnamed: L17.1 (DOUT), L23.3 (DIN)
unnamed: L18.3 (DIN), L24.1 (DOUT)
unnamed: L20.3 (DIN), L21.1 (DOUT)
unnamed: L22.3 (DIN), L25.1 (DOUT)
unnamed: L23.1 (DOUT), L26.3 (DIN)
unnamed: L24.3 (DIN), L27.1 (DOUT)
unnamed: L25.3 (DIN), L26.1 (DOUT)
unnamed: L27.3 (DIN), L28.1 (DOUT)
unnamed: L6.1 (DOUT), L28.3 (DIN)
SCL: JP4.1, JP7.1, R2.2, U1.6 (SCL)
SDA: JP5.1, JP6.1, R1.2, U1.5 (SDA)
VCC: J1.D, J3.3, JP3.1, JP8.1, L1.4 (VDD), L2.4 (VDD), L3.4 (VDD), L4.4 (VDD), L5.4 (VDD), L6.4 (VDD), L7.4 (VDD), L8.4 (VDD), L9.4 (VDD), L10.4 (VDD), L11.4 (VDD), L12.4 (VDD), L13.4 (VDD), L14.4 (VDD), L15.4 (VDD), L16.4 (VDD), L17.4 (VDD), L18.4 (VDD), L19.4 (VDD), L20.4 (VDD), L21.4 (VDD), L22.4 (VDD), L23.4 (VDD), L24.4 (VDD), L25.4 (VDD), L26.4 (VDD), L27.4 (VDD), L28.4 (VDD), R1.1, R2.1, U1.21 (VCC)
col0: SW1.1, SW7.1, SW13.1, U1.20 (F4)
col1: SW2.1, SW8.1, SW14.1, U1.19 (F5)
col2: SW3.1, SW9.1, SW15.1, SW22.1, U1.18 (F6)
col3: SW4.1, SW10.1, SW16.1, SW19.1, U1.17 (F7)
col4: SW5.1, SW11.1, SW17.1, SW20.1, U1.16 (B1)
col5: SW6.1, SW12.1, SW18.1, SW21.1, U1.15 (B3)
data: JP1.1, U1.2 (RX)
reset: RSW1.1, U1.22 (RST)
row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.7 (D4)
row1: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.8 (C6)
row2: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U1.9 (D7)
row3: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), U1.10 (E6)

Board: 2 copper layers, 133.8 x 92.2 mm, 84 parts (4 on the bottom side), 69 nets.

## Commit log

2025-03-19 Editted PCB
